v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
L 7 380 -770 380 -100 {}
L 7 40 -770 40 -100 {}
T {Simulation} 90 -760 0 0 0.8 0.8 {}
C {TOP.sym} 600 -640 0 0 {name=x1}
C {devices/title.sym} 180 -70 0 0 {name=l5 author="Copyright 2023 IHP PDK Authors"}
C {devices/launcher.sym} 110 -820 0 0 {name=h1
descr="IHP_AC3E"
url="https://github.com/IHP-GmbH/IHP-Open-PDK/tree/main"}
C {TOP_ldo_closeloop_tb.sym} 210 -660 0 0 {name=x2}
C {TOP_ldo_openloop_tb.sym} 210 -610 0 0 {name=x3}
C {devices/launcher.sym} 570 -490 0 0 {name=h2
descr="Pin-List"
url="https://github.com/IHP-GmbH/IHP-Open-PDK/tree/main"}
